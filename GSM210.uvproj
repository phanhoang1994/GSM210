# Keil uVision project GSM210.uvproj, settings and files
target TIVA Keil C (ARM-ADS)
  device: TM4C123AE6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Out +hex
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_TM4C123AE6PM TARGET_IS_TM4C123_RB1
  c include: ..\..\..\..\ti\TivaWare_C_Series-2.1.4.178
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Libraries
    ../../../../ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
  group inc
    ./inc/: config.h event.h global.h gsm.h gsm210.h idletask.h sysclock.h task.h uart6.h uart4.h
  group Source
    ./: event.c main.c sysclock.c task.c uart6.c startup_rvmdk.S uart4.c gsm.c
